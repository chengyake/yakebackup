# Keil uVision project ota.uvproj, settings and files
target ota (ARM-ADS)
  device: QN9020 Quintic
  cpu: IRAM(0x00008000-0x0000FFFF) IROM(0x00000000-0x00007FFF) CLOCK(16000000) CPUTYPE("Cortex-M0")
  output: ota
  AfterMake: fromelf --bin --output ./bin/ota.bin ./obj/ota.axf
  c flags: Optim=4 OneElfS=1
  c misc: --C99
  c include: ..\..\src\fw;..\..\src\profiles;..\..\src\profiles\prox\proxr;..\..\src\profiles\ota\otas;..\..\src\app;..\..\src\app\gap;..\..\src\app\gatt;..\..\src\app\smp;..\..\src\app\proxr;..\..\src\cmsis;..\..\src\driver;..\..\src\lib;..\..\src\qnevb;..\src;..\..\src\app\qpps;..\..\src\profiles\qpp\qpps;..\..\src\profiles\qpp
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x8000 size 0x8000
  scatter file: ..\..\src\link\keil\qn9020_link.sct
  link misc: --no_autoat --remove
  group startup
    ../../src/startup/keil/: startup.s
  group main
    ../../src/main/: app_main.c
  group usr
    ../src/: system.c usr_design.c
  group app
    ../../src/app/: app_util.c app_env.c app_printf.c app_sys.c app_task.c
    ../../src/app/gap/: app_gap.c app_gap_task.c
    ../../src/app/gatt/: app_gatt.c app_gatt_task.c
    ../../src/app/smp/: app_smp.c app_smp_task.c
    ../../src/app/proxr/: app_proxr.c app_proxr_task.c
    ../../src/app/qpps/: app_qpps.c app_qpps_task.c
  group profiles
    ../../src/profiles/: prf_utils.c
    ../../src/profiles/prox/proxr/: proxr.c proxr_task.c
  group drivers
    ../../src/driver/: uart.c gpio.c sleep.c syscon.c pwm.c wdt.c timer.c rtc.c dma.c serialflash.c
  group lib
    ../../src/lib/keil/: qn9020b2_lib_peripheral.lib
    ../../src/profiles/ota/otas/: qn_ota.lib
    ../../src/profiles/qpp/qpps/: qn_qpp.lib
  group qnevb
    ../../src/qnevb/: led.c button.c buzz.c
  group retarget
    ../../src/retarget/: retarget.c
